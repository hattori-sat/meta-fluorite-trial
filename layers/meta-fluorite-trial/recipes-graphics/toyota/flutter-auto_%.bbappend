FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0002-fix-initialize-custom-camera-base-mode.patch;patchdir=ivi-homescreen-plugins"
