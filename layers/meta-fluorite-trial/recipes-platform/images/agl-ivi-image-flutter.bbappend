IMAGE_INSTALL:append = " agl-driver-shell-env weston-ini-conf-landscape"
