SUMMARY = "Fluorite demo package group"
DESCRIPTION = "Project-owned package group for the Fluorite Flutter demo."
LICENSE = "MIT"

inherit packagegroup

RDEPENDS:${PN} = " \
    toyota-connected-tcna-packages-filament-scene-fluorite-examples-demo \
"
