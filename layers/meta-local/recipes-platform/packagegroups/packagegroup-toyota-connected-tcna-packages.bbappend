# Fluorite validation does not use the Toyota video-player example.
RDEPENDS:${PN}:remove = "toyota-connected-tcna-packages-video-player-video-player-linux-video-player-example"
